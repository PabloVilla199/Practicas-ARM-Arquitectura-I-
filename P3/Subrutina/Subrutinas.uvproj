# Keil uVision project Subrutinas.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2888 NXP (founded by Philips)
  cpu: IRAM(0x400000-0x40FFFF) IROM(0x10400000-0x104FFFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: Subrutinas
  c flags: Optim=1
  memory RVCT4: ROM 0x10400000 size 0x100000
  memory RVCT9: RAM 0x400000 size 0x10000
  scatter file: ..\..\P2\P2_2-20240211T194642Z-001\P2_2\practica2_2.sct
  group Source Group 1
    ../../P2/P2_2-20240211T194642Z-001/P2_2/: practica2_2.s
